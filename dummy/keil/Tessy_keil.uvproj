# Keil uVision project Tessy_keil.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Tessy_keil
  c flags: Optim=1
  c define: DUMMY, HSE_VALUE
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s system_stm32f4xx.c
  group main
    ./src/: main.c
  group Dummy
    ./src/: dummy_can.c
target Tessy_Simulator (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: ts_slave.hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
